Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: c13bbd3e-c96b-4738-b5aa-4b8856a6dcf2, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-09T22:02:30+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12619440_NER_H7860BPX_PEBE:22786095_NER_12619440_H7860BPX_PEBE, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_PEBE, <Unnamed>, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 595 mm; Height: 596 mm; Depth: 568 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 22786095_NER_12619440_H7860BPX_PEBE; sets with these values: 2

# IfcDistributionPort, Port_354101_1
Description: Flow; FlowDirection: SOURCEANDSINK
